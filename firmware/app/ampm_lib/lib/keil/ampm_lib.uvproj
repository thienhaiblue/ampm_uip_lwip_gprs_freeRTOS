# Keil uVision project ampm_lib.uvproj, settings and files
target ampm_lib (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ampm_lib (library)
  c flags: Optim=1
  c include: ..\..\..\ampm_lib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ampm_lib
    ../: data_cmp.c fcs.c m_time.c packet_queue.c protocol.c ringbuf.c sparser.c sys_time.c sys_tick.c encoding.c ampm_list.c ampm_sprintf.c DTMF.c
