# Keil uVision project uip-ppp-lib.uvproj, settings and files
target uip-pp-lib (ARM-ADS)
  device: LPC1764 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10003FFF) IRAM2(0x2007C000-0x2007FFFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: uip-ppp-lib (library)
  c flags: Optim=1
  c include: ..\PPP;..\uip;..\uip-ppp-lib;..\..\ampm_lib;..\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group sources
    ../uip/: resolv.c timer.c uip.c uip_ppp.c resolver.c tcpip.c
    ../PPP/: fcs.c ppp.c xtea.c
