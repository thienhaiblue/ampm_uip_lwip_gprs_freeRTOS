# Keil uVision project bt1.uvproj, settings and files
target AMPM_IOT_RELEASE (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PJ2000ST +hex
  AfterMake: fromelf --bin --output .\output\PJ2000STV3.03.bin .\flash\PJ2000ST.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\..\driver\STM32F10x_StdPeriph_Driver\inc;..\..\CMSIS\CM3\CoreSupport;..\..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\inc;..\..\ampm_lib;..\..\driver;..\..\ampm_lib\ampm_gsm;..\..\driver\ampm\stm32;..\..\ampm_lib\db;..\..\ampm_lib\flash_mem;..\..\ampm_lib\accelerometer\lis3dh;..\..\ampm_lib\accelerometer\mma7660;..\..\ampm_lib\accelerometer;..\..\ampm_lib\PPP;..\..\ampm_lib\uip;..\..\ampm_lib\uip-ppp-lib;..\..\ampm_lib\gsm\ampm_gsm\sms;..\..\ampm_lib\flash_mem;..\..\ampm_lib\common;..\..\wolfssl;..\..\src\wolfSSL;..\..\FreeRTOS\FreeRTOS\Source\include;..\..\FreeRTOS\FreeRTOS\Source;..\..\FreeRTOS\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\ampm_lib\uip\port\freeRTOS\arch;..\..\ampm_lib\uip\os\src\include;..\..\ampm_lib\uip\os\port\freeRTOS;..\..\ampm_lib\uip\os\src\include\ipv4;..\..\ampm_lib\dtmf
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group main
    ../../ampm_lib/ampm_gsm/: ampm_gsm_main_task.c
    ../../src/: main.c tcp_ip_task.c led.c adc_task.c dbg.c
  group uip-os
    ../../ampm_lib/uip/os/port/freeRTOS/: sys_arch.c
    ../../ampm_lib/uip/os/src/core/: sys.c memp.c mem.c pbuf.c inet.c
    ../../ampm_lib/uip/os/src/api/: api_lib.c api_msg.c sockets.c
  group uip
    ../../ampm_lib/uip/: uip.c resolv.c timer.c uip_ppp.c tcpip.c resolver.c tcpip_rtos.c
  group ppp
    ../../ampm_lib/PPP/: ppp.c xtea.c fcs.c
  group freeRTOS
    ../../FreeRTOS/FreeRTOS/Source/: queue.c tasks.c list.c
    ../../FreeRTOS/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../FreeRTOS/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group common_lib
    ../../ampm_lib/common/: comm.c
    ../../ampm_lib/lib/keil/Output/: ampm_lib.lib
    ../../ampm_lib/ampm_gsm/keil/Flash/: ampm_gsm.lib
    ../../ampm_lib/ampm_gsm/: ampm_gsm_call.c ampm_gsm_common.c ampm_gsm_dial_up.c ampm_gsm_io.c ampm_gsm_ring.c ampm_gsm_sms.c ampm_gsm_startup.c at_command_parser.c
    ../../ampm_lib/ampm_gsm/sms/: pdu.c
    ../../ampm_lib/dtmf/: DTMF_app.c
    ../../ampm_lib/lib/: m_time.c sys_time.c
  group driver
    ../../ampm_lib/lib/: tick.c
    ../../driver/STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_dma.c
    ../../driver/ampm/stm32/: uart1.c rtc.c uart3.c spi.c
  group CMSIS
    ../../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group wolfssl-crypt
    ../../wolfssl/wolfcrypt/src/: aes.c arc4.c asm.c asn.c blake2b.c camellia.c chacha.c chacha20_poly1305.c coding.c compress.c curve25519.c des3.c dh.c dsa.c ecc.c ecc_fp.c ed25519.c error.c fe_low_mem.c fe_operations.c ge_low_mem.c ge_operations.c hash.c hc128.c hmac.c idea.c integer.c logging.c md2.c md4.c md5.c memory.c misc.c pkcs7.c poly1305.c pwdbased.c rabbit.c random.c ripemd.c rsa.c sha.c sha256.c sha512.c signature.c srp.c tfm.c wc_encrypt.c wc_port.c
  group wolfssl-ssl
    ../../wolfssl/src/: crl.c internal.c io.c keys.c ocsp.c sniffer.c ssl.c tls.c
  group wolfssl-config
    ../../src/wolfSSL/: config.h config-FS.h
  group ampm-ff
    ../../ampm_lib/flash_mem/: sst25.c
    ../../ampm_lib/ampm_ff/: ampm_ff.c ampm_ff_port.c
