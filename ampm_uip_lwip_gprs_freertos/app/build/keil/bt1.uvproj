# Keil uVision project bt1.uvproj, settings and files
target GT1025_RELEASE (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PJ2000ST +hex
  AfterMake: fromelf --bin --output .\output\PJ2000STV3.03.bin .\flash\PJ2000ST.axf
  c flags: Optim=1
  c define: HAVE_CONFIG_H STM32F10X_HD,USE_STDPERIPH_DRIVER MDK_CONF_FS
  c include: ..\..\driver\STM32F10x_StdPeriph_Driver\inc;..\..\CMSIS\CM3\CoreSupport;..\..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\inc;..\..\ampm_lib;..\..\driver;..\..\ampm_lib\ampm_gsm;..\..\driver\ampm\stm32;..\..\ampm_lib\db;..\..\ampm_lib\flash_mem;..\..\ampm_lib\accelerometer\lis3dh;..\..\ampm_lib\accelerometer\mma7660;..\..\ampm_lib\accelerometer;..\..\ampm_lib\PPP;..\..\ampm_lib\uip;..\..\ampm_lib\uip-ppp-lib;..\..\ampm_lib\gsm\ampm_gsm\sms;..\..\ampm_lib\FATFS;..\..\ampm_lib\flash_mem;..\..\ampm_lib\common;..\..\wolfssl;..\..\src\wolfSSL;..\..\FreeRTOS\FreeRTOS\Source\include;..\..\FreeRTOS\FreeRTOS\Source;..\..\FreeRTOS\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\ampm_lib\uip\port\freeRTOS\arch;..\..\ampm_lib\uip\os\src\include;..\..\ampm_lib\uip\os\port\freeRTOS;..\..\ampm_lib\uip\os\src\include\ipv4
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group main
    ../../ampm_lib/ampm_gsm/: ampm_gsm_main_task.c
    ../../src/: main.c tcp_ip_task.c led.c
  group uip-os
    ../../ampm_lib/uip/os/port/freeRTOS/: sys_arch.c
    ../../ampm_lib/uip/os/src/core/: sys.c memp.c mem.c pbuf.c inet.c
    ../../ampm_lib/uip/os/src/api/: api_lib.c api_msg.c sockets.c
  group uip
    ../../ampm_lib/uip/: uip.c resolv.c timer.c uip_ppp.c tcpip.c resolver.c tcpip_rtos.c
  group ppp
    ../../ampm_lib/PPP/: ppp.c xtea.c fcs.c
  group freeRTOS
    ../../FreeRTOS/FreeRTOS/Source/: queue.c tasks.c list.c
    ../../FreeRTOS/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../FreeRTOS/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group common_lib
    ../../ampm_lib/common/: comm.c
    ../../ampm_lib/lib/keil/Output/: ampm_lib.lib
    ../../ampm_lib/ampm_gsm/keil/Flash/: ampm_gsm.lib
  group driver
    ../../ampm_lib/lib/: tick.c
    ../../driver/STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_gpio.c stm32f10x_rcc.c
    ../../driver/ampm/stm32/: uart1.c exti.c rtc.c
  group CMSIS
    ../../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
target GT1025_DEBUG (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: as above
  output: PJ2000ST +hex
  AfterMake: fromelf --bin --output .\debug\output\PJ2000STV2.43.bin .\debug\PJ2000ST.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,DEBUG_MODE,GSM_DEBUG_UART3_NC
  c include: ..\..\driver\STM32F10x_StdPeriph_Driver\inc;..\..\CMSIS\CM3\CoreSupport;..\..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\inc;..\..\ampm_lib;..\..\driver;..\..\ampm_lib\ampm_gsm;..\..\driver\ampm\stm32;..\..\ampm_lib\db;..\..\ampm_lib\flash_mem;..\..\ampm_lib\accelerometer\lis3dh;..\..\ampm_lib\accelerometer\mma7660;..\..\ampm_lib\accelerometer;..\..\ampm_lib\PPP;..\..\ampm_lib\uip;..\..\ampm_lib\uip-ppp-lib;..\..\ampm_lib\ampm_gsm\sms;..\..\ampm_lib\FATFS;..\..\ampm_lib\flash_mem;..\..\ampm_lib\common;..\..\ampm_lib\ftp
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
